# IAR project RFID.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4; TRACE_LEVEL=4; DEBUG
  ICCARM.CCIncludePath2: ..\AS3910; ..\Interface; ..\at91lib; ..\at91lib\boards\H82G3_V1; ..\at91lib\boards\H82G3_V1\at91sam3u4; ..\at91lib\peripherals\; ..\at91lib\utility\; ..\EMV; ..\external_libs\cmsis; ..\hw_drivers; ..\Interface; ..\Source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RFID.srec
  ILINK.IlinkOutputFile: RFID.out
  ILINK.IlinkIcfFile: ..\at91lib\boards\H82G3_V1\at91sam3u4\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; TRACE_LEVEL=4; NDEBUG
  OBJCOPY.OOCOutputFile: RFID.hex
  ILINK.IlinkIcfFile: C:\Users\Administrator\Desktop\测试工程\at91lib\boards\H82G3_V1\at91sam3u4\flash.icf
  group (top)
    ../: Read.txt
  group AS3910
    ../AS3910/: as3910_com.c as3910_interrupt.c as3910_io.c as3910_transparentmode.c
  group at91lib/boards
    ../at91lib/boards/H82G3_V1/: board.h board_cstartup_iar.c board_lowlevel.c board_lowlevel.h board_memories.c board_memories.h exceptions.c exceptions.h
  group at91lib/boards/cpu
    ../at91lib/boards/H82G3_V1/at91sam3u4/: AT91SAM3U4.h chip.h flash.icf
  group at91lib/peripherals/dbgu
    ../at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/irq
    ../at91lib/peripherals/irq/: irq.h nvic.c
  group at91lib/peripherals/pio
    ../at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pmc
    ../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/systick
    ../at91lib/peripherals/systick/: systick.c systick.h
  group at91lib/peripherals/tc
    ../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/utility
    ../at91lib/utility/: assert.h trace.c trace.h
  group external_libs/cmsis
    ../external_libs/cmsis/: core_cm3.c core_cm3.h
  group hw_drivers
    ../hw_drivers/: spi_driver.c timer_driver.c
  group Source
    ../Source/: crapto1.c main.c other.c sleep.c
